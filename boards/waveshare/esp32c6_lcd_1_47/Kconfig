## boards/waveshare/esp32c6_lcd_1_47/Kconfig
```kconfig
config HEAP_MEM_POOL_ADD_SIZE_BOARD
	int
	default 4096 if BOARD_ESP32C6_LCD_1_47_ESP32C6_HPCORE
```
